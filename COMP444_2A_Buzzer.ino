int speakerPin = 10;

void setup() {
pinMode(speakerPin, OUTPUT);
}

void loop() {
play('g',2);
play('g',1);
play('a',4);
play('g',4);
play('C',4);
play('b',4);

play(' ',2);

play('g',2);
play('g',1);
play('a',4);
play('g',4);
play('D',4);
play('C',4);

play(' ',2);

play('g',2);
play('g',1);
play('G',4);
play('E',4);
play('C',4);
play('b',4);
play('a',4);

play(' ',2);

play('F',2);
play('F',1);
play('E',4);
play('C',4);
play('D',4);
play('C',6);

while (true) {}
}

void play(char note, int beats)
{
  int numNotes = 14;

  char notes[] = { 'c', 'd', 'e', 'f', 'g', 'a', 'b', 'C', 'D', 'E', 'F', 'G', 'A', 'B', ' '};

  int frequencies[] = {131, 147, 165, 175, 196, 220, 247, 262, 294, 330, 349, 392, 440, 494, 0};

  int currentFrequency = 0;
  int beatLength = 150; // 2A
  int beatLength = 25; // CC Change the Tempo - Fast 
  int beatLength = 300; // CC Change the Tempo Slow

  for (int i = 0; i < numNotes; i++)
  {
    if (notes[i] == note)
    {
      currentFrequency = frequencies[i];
    }
  }

  tone(speakerPin, currentFrequency, beats * beatLength);
  delay(beats*beatLength);
  delay(50);
}

